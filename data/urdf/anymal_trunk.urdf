Commit message: add mass in rom urdf

File: data/urdf/anymal_trunk.urdf (robot description, URDF)
Before this commit: robot anymal_all, 1 links, 0 joints
Links:
- link base_link: mass None -> 30.47
